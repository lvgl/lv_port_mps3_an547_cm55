# Keil uVision project lv_template.uvprojx, settings and files
target Cortex-M55_FVP (6210000::V6.21::ARMCLANG)
  device: SSE-300-MPS3 ARM
  pack: ARM.V2M_MPS3_SSE_300_BSP.1.5.0
  cpu: IRAM(0x00000000,0x00080000) IRAM2(0x01000000,0x00200000) XRAM(0x20000000,0x00020000) XRAM2(0x20020000,0x00020000) XRAM3(0x20040000,0x00020000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: lv_template
  c flags: Optim=1 OneElfS=1 v6Lang=6 v6LangP=3 wLevel=3
  c define: USE_EVR_FOR_STDOUR,LV_USE_DEV_VERSION
  c misc: -fdata-sections -Wno-undef
  c include: .\platform;.;.\ui
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT7: RAM 0x20020000 size 0x20000
  memory RVCT8: RAM 0x20040000 size 0x20000
  memory RVCT9: RAM 0x0 size 0x80000
  memory RVCT10: RAM 0x1000000 size 0x200000
  scatter file: .\RTE\Device\SSE-300-MPS3\fvp_sse300_mps3_s.sct
  link misc: --diag_suppress=6314
  group platform
    ./platform/: led_port.c led_port.h serial.c serial.h platform.c platform.h GLCD_V2M-MPS3_AN547.c GLCD_Config.h GLCD_Fonts.c Touch_V2M-MPS3.c
  group Documentation
    ./: Abstract.txt
  group application
    ./: main.c app_cfg.h
  group lv_gpu_arm2d
    ./: lv_gpu_arm2d.c lv_gpu_arm2d.h
    ./arm2d/: lv_draw_sw_arm2d.h lv_draw_sw_helium.h
target Cortex-M55_MPS3 (6230000::V6.23::.\ArmCompilerforEmbedded6.24)
  device: SSE-300-MPS3 ARM
  pack: ARM.V2M_MPS3_SSE_300_BSP.1.5.0
  cpu: as above
  output: lv_template
  c flags: Optim=5 OneElfS=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c define: USE_EVR_FOR_STDOUR
  c include: .\platform;.;.\ui
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT7: RAM 0x20020000 size 0x20000
  memory RVCT8: RAM 0x20040000 size 0x20000
  memory RVCT9: RAM 0x0 size 0x80000
  memory RVCT10: RAM 0x1000000 size 0x200000
  scatter file: .\RTE\Device\SSE-300-MPS3\fvp_sse300_mps3_s.sct
  link misc: --diag_suppress=6314
software components: Acceleration:Arm-2D:Alpha-Blending 1.2.2-dev, Acceleration:Arm-2D:Core 1.2.2-dev, Acceleration:Arm-2D:Transform 1.2.2-dev, CMSIS Driver:USART 1.0.0, CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDOUT:Event Recorder 1.1.0, CMSIS-View:Event Recorder 1.6.0, CMSIS:CORE 6.1.0, CMSIS:DSP 1.16.2, Device:Definition 2.0.0, Device:Native Driver:SPI 1.2.0, Device:Native Driver:SysCounter 1.1.0, Device:Native Driver:SysTimer 1.1.0, Device:Native Driver:Timeout 1.0.0, Device:Native Driver:UART 1.1.0, Device:Startup 2.0.0, Utilities:perf_counter:Core 2.4.0, LVGL:Demos:Assets 9.3.0-dev2, LVGL:Demos:Widgets 9.3.0-dev2, LVGL:Essential 9.3.0-dev2, LVGL:Porting:Display 9.3.0-dev2, LVGL:Porting:Input 9.3.0-dev2
